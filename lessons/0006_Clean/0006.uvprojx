# Keil uVision project 0006.uvprojx, settings and files
target 0005 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 0005 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\workspace;.\workspace\Code\inc;.\workspace\Code\src;.\workspace\FreeRTOS\inc;.\workspace\FreeRTOS\inc;.\workspace\Startup;.\workspace\CMSIS\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Code
    ./workspace/Code/src/: main.c initSys.c libPWM.c libUART.c libLCD.c
  group CMSIS
    ./workspace/CMSIS/src/: system_stm32f4xx.c
  group FreeRTOS
    ./workspace/FreeRTOS/src/: croutine.c event_groups.c heap_1.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
  group Startup
    ./workspace/Startup/: startup_stm32f407xx.s
